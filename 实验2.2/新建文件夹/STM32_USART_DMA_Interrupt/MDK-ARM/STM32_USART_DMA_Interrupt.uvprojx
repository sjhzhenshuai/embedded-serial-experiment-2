# Keil uVision project STM32_USART_DMA_Interrupt.uvprojx, settings and files
target STM32_USART_DMA_Interrupt (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_USART_DMA_Interrupt +hex
  c flags: Optim=4
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ..\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc
  group Core
    ../Core/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
  group HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c
  group Startup
    ./: startup_stm32f103xb.s
